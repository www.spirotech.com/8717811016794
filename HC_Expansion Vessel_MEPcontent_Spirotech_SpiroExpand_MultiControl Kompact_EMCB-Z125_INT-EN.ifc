Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], RevitIdentifiers [ContentGUID: , VersionGUID: f3a51646-a1de-4539-a2f9-f600db158adc, NumberOfSaves: 173]
File name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_EMCB-Z125_INT-EN.ifc
Time: 2025-08-05T18:19:28+02:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.60.36 (ENG) - IFC 23.4.0.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuildingStorey: Level:Floor Level (3)
Pset_BuildingStoreyCommon - Reference: Floor Level
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Structural: no
Other(Type) - Category: Levels; Family Name: Level
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Name | LongName = Name | Elevation (mm) = Constraints, Elevation (mm)
F00 | F00 | 0
F01 | F01 | 3300
F02 | F02 | 6600

# IfcBuildingElementProxy: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN:EMCB-Z125, HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN:EMCB-Z125:1768046
In: F00
Type - Material: Color RGB 040-040-040, Color RAL 1003
Type - Other - Category: Mechanical Equipment; Connection Axis Z: 277.26 mm; Connection Diameter: 25.4 mm; Connector Axis X: 157.3 mm; Connector Axis Y: 338.5 mm; Connector Distance: 285.76 mm; Connector Height: 240.7 mm; Drain Geometry: yes; Drain Position-Back: 440 mm; Drain Position-Elevation: 923 mm; Drain Position-Right: 273.77 mm; Drain Revolve Start Angle: -12.9 deg; EMCK-125 Expansion Vessel: yes; EMCK-200 Expansion Vessel: no; EMCK-300 Expansion Vessel: no; EMCK-500 Expansion Vessel: no; EMCK-75 Expansion Vessel: no; Family Name: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Diameter: 500 mm; Drain Diameter: 50 mm; Height: 1405 mm; Use Nominal Diameter: yes
Type - Identity Data - Article Description: Secundary Expansion vessel MultiControl Kompact 125 ltr; Article Type: EMCB-Z125; Base Family Version: 25.09; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Secundary Expansion vessel MultiControl Kompact 125 ltr; EMCS Version: 5.0; ETIM Article Class: EC010958; Family Version: 12.24; GLN: 8717811000007; GTIN: 8717811016794; Manufacturer: Spirotech; Manufacturer Art. No.: EMCB-Z125; Manufacturer URL: https://www.spirotech.com/8717811016794; MEPcontent Class: EXPANSIONVESSEL; Model: EMCB-Z125; OmniClass Number: 23.75.70.11.14; OmniClass Title: Expansion Vessels; Product Line: Spirotech; Revit Version: 2023; Type Name: EMCB-Z125; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 040-040-040; Gray: Color RGB 200-200-200; White: Color RGB 255-255-255; Yellow: Color RAL 1003
Type - Mechanical - Loads - Workload: 4 Pa
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_BuildingElementProxyCommon - Reference: EMCB-Z125; IsExternal: no
Pset_EnvironmentalImpactIndicators - Reference: EMCB-Z125
Other - Family: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN; Family and Type: HC_Expansion Vessel_MEPcontent_Spirotech_SpiroExpand_MultiControl Kompact_INT-EN: EMCB-Z125; Overflow Pipe Angle: 90 deg; Overflow Sets Offset: 242.12 mm; Right Sided Connections: yes; Type: EMCB-Z125; Type Id: 1768024; Vessel 1 Overflow Set Type: no
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 9.28629 m2; Volume: 0.163672 m3
Identity Data - Mark: 4
Mechanical - System Classification: Sanitary,Undefined
Mechanical - Flow - Drain Fixture Units: 0; Flow In: 0 m3/s; Flow Out: 0 m3/s
Phasing - Phase Created: 3. New Construction

# IfcDistributionPort (3)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
InPort_1768046_1 | SINK | SystemType: SEWAGE
OutPort_1768046_2 | SOURCE
InPort_1768046_3 | SINK
